# Keil uVision project protocols.uvprojx, settings and files
target protocols (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: protocols +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_StdPeriph_Lib_V3.5.0\STM32F10x_StdPeriph_Driver\inc;..\STM32F10x_StdPeriph_Lib_V3.5.0\configuration;..\STM32F10x_StdPeriph_Lib_V3.5.0\CMSIS\CoreSupport;..\STM32F10x_StdPeriph_Lib_V3.5.0\CMSIS\DeviceSupport;..\USER;..\USER\INC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../STM32F10x_StdPeriph_Lib_V3.5.0/CMSIS/CoreSupport/: core_cm3.c
    ../STM32F10x_StdPeriph_Lib_V3.5.0/CMSIS/DeviceSupport/: system_stm32f10x.c
    ../STM32F10x_StdPeriph_Lib_V3.5.0/CMSIS/startup/: startup_stm32f10x_cl.s
  group SYS_LIB
    ../STM32F10x_StdPeriph_Lib_V3.5.0/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_systick.c
  group USER
    ../USER/SRC/: main.c stm32f10x_it.c usart.c blink.c delay.c adc.c modbus.c timmer.c crc_check.c can.c command.c moto_encoder.c io_operation.c motor_driver.c wwdg.c current_protect.c rs485.c motor_trigger.c
