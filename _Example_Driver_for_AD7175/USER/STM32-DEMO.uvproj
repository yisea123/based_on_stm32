# Keil uVision project STM32-DEMO.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\Code
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./: stm32f10x_it.c
    ../Code/: main.c uart.c GPIO.c delay.c AD7175.c SPI_By_IO.C Communication.c I2C_1.c AD5660.c 24cxx.c AD9833.c DUT_ADC.c IIC.c SPI_DUT.C TIM3.c tmp102.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
