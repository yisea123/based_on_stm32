# Keil uVision project _Driver_for_AD7190.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103V8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: _Driver_for_AD7190 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\User\Blink;..\User\delay;..\User\system_configuration;..\User\usart;..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\key;..\User\i2c;..\User\AD7190;..\User\SPI
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group blink
    ../User/Blink/: blink.c
  group delay
    ../User/delay/: delay.c
  group system_configuration
    ../User/system_configuration/: system_config.c
  group usart
    ../User/usart/: usart.c
  group user
    ../User/: main.c
  group system_lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
    ../Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_md.s
  group key
    ../User/key/: key.c
  group i2c
    ../User/i2c/: i2c.c
  group AD7190
    ../User/AD7190/: AD7190.c Communication.c
  group SPI
    ../User/SPI/: spi.c
